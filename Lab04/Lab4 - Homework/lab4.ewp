# IAR project lab4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S1958 TexasInstruments LM3S1968
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S1968
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: lab4.bin
  ILINK.IlinkOutputFile: lab4.out
  ILINK.IlinkIcfFile: lab4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    $EW_DIR$/arm/examples/TexasInstruments/Stellaris/driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: lab4.c startup.c
